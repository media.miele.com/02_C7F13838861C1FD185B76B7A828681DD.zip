Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [COBie2.4DesignDeliverable], RevitIdentifiers [VersionGUID: 46911ce7-f01c-49cc-974a-5745cdcc5cdd, NumberOfSaves: 1]
File name: 0001
Time: 2026-02-25T08:37:42+01:00
Written by: ODA SDAI 23.12
Made in: Autodesk Revit 24.0.20.20 (ENU) - IFC 24.0.20.20

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuildingElementProxy: 12886790_EU_PWM927RHDVDD_SST:51927003_EU_12886790_PWM927RHDVDD_SST, (2)
In: Default
Type - Material: z_Miele_Design_Steel_Chrom, z_Miele_Design_CLST, z_Miele_Design_Glass, Poche, z_Miele_Design_OBSW, z_Miele_Connection_Connection_Modul, <Unnamed>, z_Miele_Connection_Liquid Detergent, z_Miele_Connection_Water_OUT, z_Miele_Connection_Water_IN, z_Miele_Connection_Electric, z_Miele_Design_Zinc_Steel
Type - Pset_ProductRequirements - Category: Specialty Equipment
Pset_BuildingElementProxyCommon - Reference: 51927003_EU_12886790_PWM927RHDVDD_SST; sets with these values: 2
